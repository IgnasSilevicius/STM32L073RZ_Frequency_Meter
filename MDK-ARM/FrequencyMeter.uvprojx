# Keil uVision project FrequencyMeter.uvprojx, settings and files
target FrequencyMeter (6240000::V6.24::ARMCLANG)
  device: STM32L073RZTx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.3.0.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x802FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M0+") TZ
  output: FrequencyMeter +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32L073xx
  c include: ../Core/Inc;../Drivers/STM32L0xx_HAL_Driver/Inc;../Drivers/STM32L0xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32L0xx/Include;../Drivers/CMSIS/Include;../Drivers/ECUAL/I2C_LCD;../Drivers/util;../MDK-ARM
  memory RVCT4: ROM 0x8000000 size 0x30000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32l073xx.s
  group Application/User/Core
    ../Drivers/ECUAL/I2C_LCD/: I2C_LCD.c I2C_LCD.h I2C_LCD_cfg.c I2C_LCD_cfg.h
    ../Drivers/util/: Util.c Util.h
    ./: Mano.h
    ../Core/Src/: main.c stm32l0xx_it.c stm32l0xx_hal_msp.c
  group Drivers/STM32L0xx_HAL_Driver
    ../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_gpio.c stm32l0xx_hal_dma.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_cortex.c stm32l0xx_hal_exti.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32l0xx.c
software components: CMSIS:CORE 6.1.1
